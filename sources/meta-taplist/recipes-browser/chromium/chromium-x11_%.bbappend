PR = "r0"
FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
#PACKAGECONFIG = "use-egl kiosk-mode proprietary-codecs"
PACKAGECONFIG = "kiosk-mode"
