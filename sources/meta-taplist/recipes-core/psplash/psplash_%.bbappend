FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SPLASH_IMAGES_append = " file://psplash-taplist-img.png;outsuffix=taplist"

ALTERNATIVE_PRIORITY_psplash-taplist[psplash] = "200"