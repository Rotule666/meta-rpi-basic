FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
LIC_FILES_CHKSUM = "file://matchbox-session;endline=20;md5=6a5009efe256862edf165da7d572e0e3"